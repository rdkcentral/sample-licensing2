LICENSE_remove = "x"
