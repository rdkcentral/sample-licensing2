LICENSE_remove = "test"
